Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 3ae5d190-17e0-4346-8403-da11a259c3b1, NumberOfSaves: 1]
File name: 0001
Time: 2024-12-04T09:04:46+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11862880_CH_DAS2520_EDST:28S2520S_CH_11862880_DAS2520_EDST, (2)
In: Default
Type - Material: Výchozí Nový materiál, z_Miele_Design_Steel_Chrom, z_Miele_Design_Zinc_Steel, <Unnamed>, z_Miele_Design_CLST, Plast, z_Miele_Connection_Electric, z_Miele_Design_Cast, z_Miele_Design_GRGR
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 546 mm; Height: 436 mm; Depth: 273 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28S2520S_CH_11862880_DAS2520_EDST; sets with these values: 2

# IfcDistributionPort, Port_354661_1
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcOpeningElement: Opening, :1
In: Default
Classification: E1090320 Uniformat (Uniformat)
Pset_OpeningElementCommon - Reference: 28S2520S_CH_11862880_DAS2520_EDST; sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment
